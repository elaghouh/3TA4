# Keil uVision project Project.uvprojx, settings and files
target STM32L496G_DISCOVERY_USBH-FS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L496G_DISCOVERY_USBH-FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/BSP/STM32L496G-Discovery;../../../../../../Drivers/BSP/Components/hx8347g;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Application/User
    ../Src/: file_operations.c usbh_conf.c main.c usbh_diskio.c explorer.c menu.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM32L496G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_lcd.c stm32l496g_discovery.c stm32l496g_discovery_io.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_uart.c stm32l4xx_hal_hcd.c stm32l4xx_hal_rcc.c stm32l4xx_hal_spi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_dma.c stm32l4xx_ll_fmc.c stm32l4xx_hal_sram.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_lcd.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
software components: CMSIS:CORE 4.3.0
