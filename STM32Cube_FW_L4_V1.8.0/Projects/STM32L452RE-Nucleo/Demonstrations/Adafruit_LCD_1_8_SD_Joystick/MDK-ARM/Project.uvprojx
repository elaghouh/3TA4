# Keil uVision project Project.uvprojx, settings and files
target STM32L452RE_NUCLEO (ARM-ADS)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.3
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L452RE_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L452xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_spi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Middlewares/FatFs/Drivers
    ../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Demo/MDK-ARM
    ./: startup_stm32l452xx.s
  group Demo/User
    ../Src/: main.c fatfs_storage.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
