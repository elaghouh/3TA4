# IAR project Project.ewp, settings and files
configuration STM32L476G-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L476G_DISCO_REVB
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\STM32L476G-Discovery; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L476G-Discovery_BSP.srec
  ILINK.IlinkOutputFile: STM32L476G-Discovery_BSP.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../../Drivers/BSP/Components/lsm303c/: lsm303c.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L476G-Discovery
    ../../../../../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c stm32l476g_discovery_audio.c stm32l476g_discovery_glass_lcd.c stm32l476g_discovery_gyroscope.c stm32l476g_discovery_idd.c stm32l476g_discovery_qspi.c
  group Drivers/CMSIS
    ./: startup_stm32l476xx.s
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c
  group User
    ../Src/: audio_play.c audio_record.c gyro.c idd.c joystick.c lcdglass.c led.c main.c qspi.c stm32l4xx_it.c
