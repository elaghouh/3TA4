# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.2
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32L476G_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../Demo;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L476G_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STemWin/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_Keil.lib
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/Demo
    ../Demo/: GUIDEMO_VScreen.c GUIDEMO_Speed.c GUIDEMO_Cursor.c GUIDEMO_BarGraph.c GUIDEMO_Conf.c GUIDEMO_IconView.c GUIDEMO_Bitmap.c GUIDEMO_ImageFlow.c GUIDEMO_TransparentDialog.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Resource.c GUIDEMO.c GUIDEMO_Listview.c GUIDEMO_ColorBar.c GUIDEMO_Skinning.c GUIDEMO_Fading.c GUIDEMO_WashingMachine.c GUIDEMO_Graph.c GUIDEMO_AntialiasedText.c GUIDEMO_RadialMenu.c GUIDEMO_Treeview.c GUIDEMO_Automotive.c GUIDEMO_Intro.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval_io.c stm32l476g_eval_ts.c stm32l476g_eval_sram.c stm32l476g_eval.c stm32l476g_eval_nor.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_ll_fmc.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dma.c stm32l4xx_hal_nor.c stm32l4xx_hal_rtc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: LCDConf_stm32l476g_eval.c GUIConf_stm32l476g_eval.c
  group Application/User
    ../Src/: calibration.c rtc.c stm32l4xx_it.c main.c
software components: CMSIS:CORE 4.3.0
